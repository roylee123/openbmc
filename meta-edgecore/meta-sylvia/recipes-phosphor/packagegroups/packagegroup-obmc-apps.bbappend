RDEPENDS_${PN}-fan-control += "sylvia-fan-watchdog"
RDEPENDS_${PN}-inventory_append_sylvia += " openpower-occ-control phosphor-cooling-type"
RDEPENDS_${PN}-extras_append_sylvia += " phosphor-webui"
