FILESEXTRAPATHS_prepend_sylvia := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-ipmid-add_func.patch \
            file://0002-ipmid_don_t_assert_attn.patch \
           "

