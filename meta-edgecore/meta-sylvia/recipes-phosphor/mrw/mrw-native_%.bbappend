FILESEXTRAPATHS_prepend_sylvia := "${THISDIR}/${PN}:"
SRC_URI_append_sylvia += "file://sylvia.xml.patch.xml"
